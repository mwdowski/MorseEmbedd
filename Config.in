## Config.in
```kconfig
config BR2_PACKAGE_MORSE
    bool "morse"
    depends on BR2_PACKAGE_LIBGPIOD
    help
        Morse app by Michal Wdowski
```
